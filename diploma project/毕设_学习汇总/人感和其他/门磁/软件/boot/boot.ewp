# IAR project boot.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EM357 Ember EM357
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FLASH_CS_PB4; BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_NULL; BOARD_DEV0680; BTL_HAS_UART; BOOTLOADER_8K; BOOTLOADER_TYPE=BL_EXT_TYPE_SERIAL_UART; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\STACK\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\HAL\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\HAL\micro\cortexm3\bootloader
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_NULL; BOARD_DEV0680; BTL_HAS_UART; BOOTLOADER_8K; BOOTLOADER_TYPE=BL_EXT_TYPE_SERIAL_UART; __SOURCEFILE__="$FILE_FNAME$"
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: boot.hex
  postbuild: ..\..\tools\bin\otaconv.exe boot=..\..\build\boot-cortexm3-iarboot-em357-null-dev0680\boot.hex
  ILINK.IlinkOutputFile: boot.out
  ILINK.IlinkConfigDefines: BTL_SIZE=8K; BOOTLOADER=1
  ILINK.IlinkIcfFile: ..\iar-cfg-em357.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/app-bootloader-library-cortexm3-iarboot-em357-null/: app-bootloader-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/hal/micro/cortexm3/bootloader/: at45db021d.c bootloader-gpio.c bootloader-uart.c cstartup-iar-boot-entry.s79 spiflash-class1.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/hal/micro/generic/: crc.c mem-util.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/hal/micro/cortexm3/: led.c mfg-token.c micro-common.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/standalone-bootloader-library-cortexm3-iarboot-em357-null/: standalone-bootloader-library.a
  group boot
    ../../src/boot/: boot.c bootloader-uart.c cstartup-iar-boot-entry.s79 cstartup-iar-boot.c spiflash-class1.c spiFlash.c spiflash.h write_bl.c
