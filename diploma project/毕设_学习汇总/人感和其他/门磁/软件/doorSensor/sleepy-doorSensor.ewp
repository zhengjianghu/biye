# IAR project sleepy-doorSensor.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMBER_PACKET_BUFFER_COUNT=32; EMBER_INDIRECT_TRANSMISSION_TIMEOUT=7680; CONFIGURATION_HEADER="c4/c4_stack_config.h"; APPLICATION_TOKEN_HEADER="zoi/zoi_token.h"; BOARD_HEADER="zoi/zoi_board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; xBOARD_DEV0680; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; C4_SECURITY_ENABLED; EMBER_SERIAL1_TX_QUEUE_SIZE=256; EMBER_SERIAL1_RX_QUEUE_SIZE=64; APP_SERIAL=1; EMBER_SERIAL0_DEBUG; xEMBER_APPLICATION_HAS_CHILD_JOIN_HANDLER; __SOURCEFILE__="$FILE_FNAME$"; APP_INFO_PRINT_ENABLE; APP_SERIAL=1; ZCL_UTIL_MESSAGING_MESSAGE_SIZE=44
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\stack\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\hal\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\hal\micro\; ..\..\src\; ..\..\src\sleep\; ..\..\inc\; ..\..\inc\IAR\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: CONFIGURATION_HEADER="wrb/wrb-config.h"; BOARD_HEADER="wrb/wrb-board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; xBOARD_DEV0680; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; HA_LIGHT; ZA_HA_SECURITY_ENABLED; EMBER_SERIAL1_TX_QUEUE_SIZE=256; EMBER_SERIAL1_RX_QUEUE_SIZE=64; APP_SERIAL=1; xEMBER_SERIAL0_DEBUG
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\STACK\; ..\..\..\..\3rd-party-library\EmberZNet5.1.2-GA\HAL\; ..\..\lib\src\
  OBJCOPY.OOCOutputFile: sleepy-doorSensor.hex
  ILINK.IlinkOutputFile: sleepy-doorSensor.out
  ILINK.IlinkIcfFile: ../../../../3rd-party-library/EmberZNet5.1.2-GA/hal/micro/cortexm3/em35x/em357/iar-cfg.icf
  ILINK.IlinkAdditionalLibs: ..\..\lib\STM32_NOOS\libloggernoosstm32iard.a
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group c4
    ../../src/c4/: c4.c c4.h c4_cfg.h c4_common_main.c c4_common_main.h c4_keys.c c4_security.c c4_stack_config.h
  group common
    ../../src/common/: ZEvent.c ZEvent.h ZRunTime.h ZType.h
  group sleep
    ../../src/sleep/: sleep_adc.c sleep_adc.h sleep_button.c sleep_button.h sleep_button_cfg.h sleep_types.h
  group stack/archive
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/alarm-stub-library-cortexm3-iar-em357-em3xx/: alarm-stub-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/packet-validate-library-cortexm3-iar-em357-em3xx/: packet-validate-library.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/security-library-core-end-device-cortexm3-iar-em357-em3xx/: security-library-core-end-device.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/zigbee-pro-leaf-stack-cortexm3-iar-em357-em3xx/: zigbee-pro-leaf-stack.a
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
  group stack/hal
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/hal/micro/cortexm3/: adc.c buzzer.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 mfg-token.c micro-common.c micro.c sleep.c token-def.c token.c uart.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/hal/: ember-configuration.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/hal/micro/cortexm3/em35x/em357/: mpu.c
  group stack/util
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/app/util/counters/: counters.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/app/util/common/: form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/app/util/zigbee-framework/: fragment.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/app/util/security/: node.c security-address-cache.c security-common.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/app/util/serial/: serial.c
    ../../../../3rd-party-library/EmberZNet5.1.2-GA/app/util/: source-route-common.c source-route.c
  group wrb
    ../../src/zoi/: doorsensor-board.h zoi_board.h zoi_token.h
    ../../src/wrb/: wrb-main.c wrb.c
  group zcl
    ../../src/zcl/: zcl.c zcl.h zcl_basic.c zcl_basic.h zcl_cfg.h zcl_gen.c zcl_onoff.h zcl_onoffswcfg.h
