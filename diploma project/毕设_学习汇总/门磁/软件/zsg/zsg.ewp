# IAR project zsg.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _HAL_SMALL_MEMUTILS_; EMBER_PACKET_BUFFER_COUNT=32; EMBER_INDIRECT_TRANSMISSION_TIMEOUT=7680; CONFIGURATION_HEADER="c4/c4_stack_config.h"; APPLICATION_TOKEN_HEADER="zsg/zsg-token.h"; BOARD_HEADER="zsg/zsg-board.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; xNULL_BTL; EMBER_SIM_EEPROM_4KB; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; CORTEXM3_EMBER_MICRO; PHY_EM3XX; xBOARD_DEV0680; EMBER_SERIAL1_MODE=EMBER_SERIAL_BUFFER; EMBER_SERIAL1_TX_QUEUE_SIZE=256; EMBER_SERIAL1_RX_QUEUE_SIZE=64; APP_SERIAL=1; EMBER_SERIAL0_DEBUG; C4_SECURITY_ENABLED; xSCAN_DEBUG_PRINT_ENABLE; EMBER_APPLICATION_HAS_INCOMING_ROUTE_ERROR_HANDLER; xEMBER_APPLICATION_HAS_CHILD_JOIN_HANDLER; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\src; ..\..\..\..\3rd-party-library\EmberZNet5.4.1-GA\; ..\..\..\..\3rd-party-library\EmberZNet5.4.1-GA\STACK\; ..\..\..\..\3rd-party-library\EmberZNet5.4.1-GA\hal\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM357; PHY_EM3XX; BOARD_DEV0680; CONFIGURATION_HEADER="app/zdo/zdo-config.h"; EMBER_SERIAL1_MODE=EMBER_SERIAL_BUFFER; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=64; EMBER_APPLICATION_HAS_CHILD_JOIN_HANDLER
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\..\3rd-party-library\EmberZNet5.4.1-GA\; ..\..\..\..\3rd-party-library\EmberZNet5.4.1-GA\STACK\; ..\..\..\..\3rd-party-library\EmberZNet5.4.1-GA\hal\
  OBJCOPY.OOCOutputFile: zsg.hex
  postbuild: ..\..\tools\bin\otaconv.exe ..\..\build\zsg-cortexm3-iar-em357\zsg.hex
  ILINK.IlinkOutputFile: zsg.out
  ILINK.IlinkIcfFile: ../iar-cfg-em357.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group c4
    ../../src/c4/: c4.c c4.h c4_cfg.h c4_keys.c c4_main.c c4_main.h c4_ota.c c4_security.c c4_stack_config.h
  group common
    ../../src/common/: ZEvent.c ZEvent.h ZType.h
  group stack/archive
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/alarm-stub-library-cortexm3-iar-em357-em3xx/: alarm-stub-library.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/binding-table-library-cortexm3-iar-em357-em3xx/: binding-table-library.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/cbke-stub-library-cortexm3-iar-em357-em3xx/: cbke-stub-library.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/end-device-bind-stub-library-cortexm3-iar-em357-em3xx/: end-device-bind-stub-library.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/hal-library-cortexm3-iar-em357-em3xx/: hal-library.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/install-code-library-stub-cortexm3-iar-em357-em3xx/: install-code-library-stub.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/multi-network-stub-library-cortexm3-iar-em357-em3xx/: multi-network-stub-library.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/packet-validate-library-cortexm3-iar-em357-em3xx/: packet-validate-library.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/security-library-core-cortexm3-iar-em357-em3xx/: security-library-core.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/security-library-link-keys-stub-cortexm3-iar-em357-em3xx/: security-library-link-keys-stub.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/zigbee-pro-stack-cortexm3-iar-em357-em3xx/: zigbee-pro-stack.a
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/build/zll-stub-library-cortexm3-iar-em357-em3xx/: zll-stub-library.a
  group stack/hal
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/hal/micro/cortexm3/: adc.c assert-crash-handlers.c bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c cstartup-iar-common.c diagnostic.c faults.s79 isr-stubs.s79 mfg-token.c micro-common.c micro.c mpu.c sleep.c token-def.c token.c uart.c
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/hal/micro/generic/: crc.c endian.c mem-util.c random.c sim-eeprom.c
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/hal/: ember-configuration.c
  group stack/util
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/app/util/serial/: cli.c ember-printf.c serial.c
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/app/util/concentrator/: concentrator.c
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/app/util/counters/: counters.c
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/app/util/common/: form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c print-stack-tables.c
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/app/util/zigbee-framework/: fragment.c zigbee-device-common.c zigbee-device-library.c
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/app/util/security/: security-address-cache.c
    ../../../../3rd-party-library/EmberZNet5.4.1-GA/app/util/: source-route-common.c source-route.c
  group zcl
    ../../src/zcl/: zcl.c zcl.h zcl_basic.c zcl_basic.h zcl_cfg.h zcl_gen.c zcl_level.h zcl_onoff.h zcl_onoffswcfg.h zcl_ota.c zcl_ota.h zcl_serial_gateway.h
  group zsg
    ../../src/zsg/: zsg-board.h zsg-token.h zsg.c zsg_serial.c zsg_serial.h
